*RPLY_BIAS_SKY130A/RPLYBS_OTA
*----------------------------------------------------------------
* Include
*----------------------------------------------------------------
#ifdef Lay
.include ../../../work/lpe/RPLYBS_OTA_lpe.spi
#else
.include ../../../work/xsch/RPLYBS_OTA_SMPL.spice
#endif

.include ../../RPLY_BIAS/lstb_probe.spi

*-----------------------------------------------------------------
* OPTIONS
*-----------------------------------------------------------------
.option TNOM=27 GMIN=1e-18

*+ gminsteps=20
*+ rshunt=1e12

*-----------------------------------------------------------------
* PARAMETERS
*-----------------------------------------------------------------

*-----------------------------------------------------------------
* FORCE
*-----------------------------------------------------------------
VSS  VSS  0     dc 0
VDD  VDD_1V8  0  dc {vdda}
VPWR PWRUP_1V8 0 dc {vdda}

VI VIP 0 dc {vcm} ac 1

* AC feedback
V2 VO VIN dc 0

C2 VO 0 1p

*-----------------------------------------------------------------
* DUT
*-----------------------------------------------------------------
IB 0 IBP_2U dc 2u
XDUT VDD_1V8 VO VSS PWRUP_1V8 VIN VIP IBP_2U RPLYBS_OTA_SMPL

*----------------------------------------------------------------
* MEASURES
*----------------------------------------------------------------

*----------------------------------------------------------------
* PROBE
*----------------------------------------------------------------

#ifdef Debug
.save all
#else
.save op v(vip) v(xdut.vs)
+ v(xdut.vbp) v(xdut.vbn1) v(xdut.vbn2) v(xdut.vbpb) v(ibp_2u)
+ i(VDD)
.probe ac v(VDD_1V8) v(VO) v(VSS) v(PWRUP_1V8) v(VIN) v(VIP)
+ v(xdut.vip_ls) v(xdut.vin_ls)
#endif

*----------------------------------------------------------------
* NGSPICE control
*----------------------------------------------------------------
.control
set num_threads=8
set color0=white
set color1=black

optran 1 1 1 100p 100n 0

set fname="{cicname}""
source ../../RPLY_BIAS/lstb_probe.ctrl

unset askquit

op
print alli
print allv

ac dec 50 1k 1G
write

quit

.endc

.end
